<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Full_STM32H503CB_VL53L4CD_Project1.ewp</path>
  </project>
  <batchBuild />
</workspace>
