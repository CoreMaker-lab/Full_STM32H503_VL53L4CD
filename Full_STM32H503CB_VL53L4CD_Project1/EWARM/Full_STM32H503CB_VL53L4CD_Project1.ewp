# IAR project Full_STM32H503CB_VL53L4CD_Project1.ewp, settings and files
configuration Full_STM32H503CB_VL53L4CD_Project1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H503CB ST STM32H503CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H503xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../TOF/App; ../TOF/Target; ../Drivers/BSP/custom; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/vl53l4cd/modules; ../Drivers/BSP/Components/vl53l4cd/porting; ../Drivers/BSP/Components/vl53l4cd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Full_STM32H503CB_VL53L4CD_Project1.hex
  ILINK.IlinkOutputFile: Full_STM32H503CB_VL53L4CD_Project1.out
  ILINK.IlinkIcfFile: stm32h503xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bsp.c icache.c custom_bus.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/User/TOF/Target
    ../TOF/Target/: custom_ranging_sensor.c
  group Application/User/TOF/App
    ../TOF/App/: app_tof.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/vl53l4cd/modules/: vl53l4cd_api.c vl53l4cd_calibration.c
    ../Drivers/BSP/Components/vl53l4cd/porting/: platform.c
    ../Drivers/BSP/Components/vl53l4cd/: vl53l4cd.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_icache.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../Drivers/BSP/Components/Components/vl53l4cd/: LICENSE.txt
